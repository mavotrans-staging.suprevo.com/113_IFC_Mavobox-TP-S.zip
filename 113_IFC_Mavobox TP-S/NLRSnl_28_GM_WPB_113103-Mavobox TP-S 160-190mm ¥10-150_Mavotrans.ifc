Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-17T14:45:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 17 14:45:29 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{B5699DE1-19C1-43E1-B89D-6DC0F664CC86}\ifc * Database version: 5507 * Database creation date: Mon Oct 17 14:45:29 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 17 14:45:29 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 17 14:45:29 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\11-Stekkenbakken; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\11-Stekkenbakken; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 113103, NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19:113103_160-190mm_Ø10/150mm:408503
In: Level 0
Type - Classification: 28 (Default Classification); Material: Rebar, ASTM A615, Grade 40
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - b (mm): 110 mm; Bakdiepte | Box height (mm): 35 mm; Baklengte | Box length (mm): 1250 mm; e (mm): 150 mm; h (mm): 150 mm; lü (mm): 390 mm; Ø (mm): 10 mm
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 113103; Beschrijving | Description: Mavobox TP-S Ø10-150; Certificaten | Certification: KOMO K102859; Laatste versie | Last version: 17-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD 400; NL-SfB code: 28; Opmerkingen | Comments: Voor het opnemen van hoge afschuifwaarden in de lengterichting. Voor aan te sluiten constructiedikte van 160-190 mm | To withstand high longitudinal shear loads. For connection construction thickness of 160-190 mm; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Name: 113103_160-190mm_Ø10/150mm; URL: https://mavotrans.nl/mavobox-tp-s.html; Verpakkingshoeveelheid | Sales packaging: Per stuk van 1250 mm | Single units of 1250 mm; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Steel B500B
Type - Other - Category: Generic Models; Box height: 35 mm; Box length: 1250 mm; Box width «B»: 140 mm; Bracket height «h»: 150 mm; Bracket length «lü»: 390 mm; Bracket width «b»: 110 mm; Diameter «Ø»: 10 mm; Family Name: NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19; Pitch «e»: 150 mm; r: 10 mm; Side offset: 100 mm
Type - Visibility - Array count «static»: 4
Type - Pset_ProductRequirements - Category: Generic Models
Description: Mavobox TP-S Ø10-150; Material: Rebar, ASTM A615, Grade 40, Plastic
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19:113103_160-190mm_Ø10/150mm; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.358698 m2; Volume: 0.00664149 m3
Other - Family: NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19: 113103_160-190mm_Ø10/150mm; Family and Type: NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19: 113103_160-190mm_Ø10/150mm; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19: 113103_160-190mm_Ø10/150mm; Type Id: NLRSnl_28_GM_WPB_113-Mavobox TP-S_Mavotrans_R19: 113103_160-190mm_Ø10/150mm
Phasing - Phase Created: New Construction
Visibility - Array count: 4; Uitgevouwen | Unfold: yes; Visibility_fold: no
